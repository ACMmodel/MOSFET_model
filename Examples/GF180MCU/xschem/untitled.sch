v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {symbol/nand2_acm.sym} 110 -40 0 0 {name=x1 m=1 VDDPIN=VDD VSSPIN=VSS}
